# Keil uVision project SysTick.uvprojx, settings and files
target SysTick (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SysTick +hex
  c flags: uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\HardWare;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\ATK_ESP8266;..\MALLOC;..\HardWare\IIC;..\HardWare\24CXX;..\HardWare\DMX512;..\HardWare\UCS2903;..\HardWare\HC05;..\HardWare\USART2;..\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c
    ../HardWare/: led.c SysTick.c usart1.c Time2.c exti.c key.c IO.C CRC16.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: mysys.c
    ../HardWare/IIC/: myiic.c
    ../HardWare/24CXX/: 24cxx.c
    ../HardWare/HC05/: hc05.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.1.0
